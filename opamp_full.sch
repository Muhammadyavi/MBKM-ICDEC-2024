v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmosds.sym} 3910 -760 0 1 {name=x1}
C {nmosds2.sym} 3440 -750 0 0 {name=x2}
C {pmoscs.sym} 3910 -850 0 1 {name=x3}
C {pmoscs2.sym} 3440 -830 0 0 {name=x4}
C {devices/lab_pin.sym} 3760 -750 0 0 {name=p3 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 3590 -730 2 0 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3760 -730 0 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 3760 -880 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3590 -860 2 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3290 -860 0 0 {name=p16 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 3290 -840 0 0 {name=p17 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 3590 -840 2 0 {name=p11 sig_type=std_logic lab=net3
}
C {devices/lab_pin.sym} 3590 -800 2 0 {name=p13 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 3590 -770 2 0 {name=p14 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 3590 -750 2 0 {name=p18 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 3590 -820 2 0 {name=p19 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 3760 -860 0 0 {name=p20 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 3760 -840 0 0 {name=p21 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 3760 -820 0 0 {name=p22 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 3760 -790 0 0 {name=p23 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 3760 -770 0 0 {name=p24 sig_type=std_logic lab=net1
}
C {devices/iopin.sym} 3650 -910 3 0 {name=p1 lab=VIP}
C {devices/iopin.sym} 3670 -910 3 0 {name=p2 lab=OUT}
C {devices/iopin.sym} 3690 -910 3 0 {name=p5 lab=RS}
C {devices/iopin.sym} 3710 -910 3 0 {name=p6 lab=GND}
C {devices/iopin.sym} 3630 -910 3 0 {name=p9 lab=VIN}
C {devices/iopin.sym} 3610 -910 3 0 {name=p10 lab=VDD}
